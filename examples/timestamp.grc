options:
  parameters:
    generate_options: qt_gui
    id: timestamp
    output_language: python
    title: timestamp
  states: {}

blocks:
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    start: 1e5
    step: 1e6
    stop: 250e6
    value: sample_rate * .8
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    start: 250e6
    step: 1e6
    stop: 6000e6
    value: 1000e6
  states: {}
- name: gain_index
  id: variable_qtgui_range
  parameters:
    label: Gain Index
    rangeType: int
    start: '0'
    step: '1'
    stop: '255'
    value: '10'
  states: {}
- name: run_rx_calibration
  id: variable_qtgui_push_button
  parameters:
    label: Run RX Calibration
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sample_rate
  id: variable_qtgui_range
  parameters:
    start: 1e6
    step: 1e6
    stop: 250e6
    value: 10e6
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_tags_strobe_0
  id: blocks_tags_strobe
  parameters:
    key: pmt.intern("strobe")
    nsamps: '5000000'
    type: complex
    value: pmt.intern("TEST")
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          ctr = 0
          last_sys = 0
          last_rf = 0
          tags_displayed = 0

          def __init__(self,  num_tags_display = 1, sample_rate = 0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Print Tags',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
             
              )
              print("init print tags")
                        
              # a callback is registered (properties work, too).
              self.num_tags_display = num_tags_display
              self.sample_rate = sample_rate
              
              
          
          def work(self, input_items, output_items):
         
              output_items[0][:] = input_items[0] * 1
              
              #print("ts", len(input_items[0]))
              tags = self.get_tags_in_window(0, 0, len(input_items[0]))
              blk.ctr += 1
              if blk.tags_displayed < self.num_tags_display:
                  if len(tags) > 0:
                      print("ctr", blk.tags_displayed, "sample_rate", self.sample_rate, "tags", len(tags), "input_items", len(input_items[0]), "\n")
                      
                      for tag in tags:
                          key = pmt.to_python(tag.key) # convert from PMT to python string
                          value = pmt.to_python(tag.value) # Note that the type(value) can be several things, it depends what PMT type it was
                          print('key:', key)
                          print('value:', value, type(value))
                          
                          
                          if key == 'sys_timestamp':
                              delta = value - blk.last_sys
                              time = delta / 40000000
                              
                              print("delta: ", delta, "time: ", time)
                              blk.last_sys = value
                          
                          if key == 'rf_timestamp':
                              delta = value - blk.last_rf
                              time = delta / self.sample_rate
                              
                              print("delta: ", delta, "time: ", time)
                              blk.last_rf = value
                              
                              
                          print(" ")
                  blk.tags_displayed += len(tags)    
              
              return len(output_items[0])
    maxoutbuf: '32000'
    minoutbuf: '8000'
    num_tags_display: '50'
    sample_rate: sample_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: frequency
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: sidekiq_sidekiq_rx_0
  id: sidekiq_sidekiq_rx
  parameters:
    bandwidth: bandwidth
    cal_mode: '2'
    cal_type: '0'
    card: '1'
    frequency: frequency
    gain_index: gain_index
    gain_mode: '1'
    handle1: '0'
    handle2: '100'
    maxoutbuf: '32000'
    minoutbuf: '8000'
    run_cal: run_rx_calibration
    sample_rate: sample_rate
  states: {}

connections:
- [blocks_add_xx_0, '0', epy_block_0, '0']
- [blocks_tags_strobe_0, '0', blocks_add_xx_0, '1']
- [epy_block_0, '0', qtgui_freq_sink_x_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']
- [sidekiq_sidekiq_rx_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
