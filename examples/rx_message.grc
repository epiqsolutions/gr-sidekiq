options:
  parameters:
    generate_options: qt_gui
    id: source_test
    output_language: python
    title: source_test
  states: {}

blocks:
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    start: 1e6
    step: 1e6
    stop: 250e6
    value: sample_rate * .8
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    start: 250e6
    step: 1e6
    stop: 6000e6
    value: 1000e6
  states: {}
- name: run_rx_calibration
  id: variable_qtgui_push_button
  parameters:
    label: Run RX Calibration
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sample_rate
  id: variable_qtgui_range
  parameters:
    start: 1e6
    step: 1e6
    stop: 250e6
    value: 10e6
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_static: 'False'
    key: lo_freq
    label: frequency_message
    type: double
    value: '1000000000'
  states: {}
- name: qtgui_edit_box_msg_1
  id: qtgui_edit_box_msg
  parameters:
    is_static: 'False'
    key: rate
    label: sample_rate_message
    type: double
    value: '10000000'
  states: {}
- name: qtgui_edit_box_msg_2
  id: qtgui_edit_box_msg
  parameters:
    is_static: 'False'
    key: bandwidth
    label: bandwidth_message
    type: double
    value: '8000000'
  states: {}
- name: qtgui_edit_box_msg_3
  id: qtgui_edit_box_msg
  parameters:
    is_static: 'False'
    key: gain
    label: gain_message
    type: double
    value: '10'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: frequency
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: sidekiq_sidekiq_rx_0
  id: sidekiq_sidekiq_rx
  parameters:
    bandwidth: bandwidth
    cal_mode: '0'
    cal_type: '0'
    card: '0'
    frequency: frequency
    gain_index: '1'
    gain_mode: '1'
    handle1: '0'
    handle2: '100'
    maxoutbuf: '16000'
    run_cal: run_rx_calibration
    sample_rate: sample_rate
  states: {}

connections:
- [qtgui_edit_box_msg_0, msg, sidekiq_sidekiq_rx_0, command]
- [qtgui_edit_box_msg_1, msg, sidekiq_sidekiq_rx_0, command]
- [qtgui_edit_box_msg_2, msg, sidekiq_sidekiq_rx_0, command]
- [qtgui_edit_box_msg_3, msg, sidekiq_sidekiq_rx_0, command]
- [sidekiq_sidekiq_rx_0, '0', qtgui_freq_sink_x_0, '0']
- [sidekiq_sidekiq_rx_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
