options:
  parameters:
    generate_options: qt_gui
    id: fm_radio
    output_language: python
    title: FM Radio
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: frequency
  id: variable_qtgui_chooser
  parameters:
    label0: ch 88.1
    label1: ch 90.1
    label2: ch 90.9
    label3: '107.9'
    num_opts: '4'
    option0: 88.1e6
    option1: 90.1e6
    option2: 90.9e6
    option3: 107.9e6
    type: real
    value: 88.1e6
    widget: radio_buttons
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '.1'
    stop: '1'
    value: '.2'
    widget: counter
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '5'
    audio_pass: '16000'
    audio_stop: '20000'
    chan_rate: sample_rate
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: sidekiq_sidekiq_rx_0
  id: sidekiq_sidekiq_rx
  parameters:
    bandwidth: bandwidth
    cal_mode: '1'
    cal_type: '0'
    card: '0'
    frequency: frequency
    gain_index: '1'
    gain_mode: '1'
    handle1: '0'
    handle2: '100'
    maxoutbuf: '16000'
    run_cal: '0'
    sample_rate: sample_rate
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [sidekiq_sidekiq_rx_0, '0', analog_fm_demod_cf_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
