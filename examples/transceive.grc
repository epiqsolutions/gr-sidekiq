options:
  parameters:
    generate_options: qt_gui
    id: transceive
    output_language: python
    title: Transceive
  states: {}

blocks:
- name: card
  id: variable
  parameters:
    value: '1'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 1000e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: frequency
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: sidekiq_sidekiq_rx_0
  id: sidekiq_sidekiq_rx
  parameters:
    bandwidth: samp_rate * .8
    cal_mode: '0'
    cal_type: '0'
    card: '0'
    frequency: frequency
    gain_index: '0'
    gain_mode: '1'
    handle1: '0'
    handle2: '100'
    maxoutbuf: '32000'
    pps_source: '0'
    run_cal: '0'
    sample_rate: samp_rate
    timestamp_tags: '0'
    trigger_src: '0'
  states: {}
- name: sidekiq_sidekiq_tx_0
  id: sidekiq_sidekiq_tx
  parameters:
    attenuation: '100'
    bandwidth: samp_rate * .8
    buffer_size: '16380'
    burst_tag: ''
    cal_mode: '0'
    card: '0'
    frequency: frequency
    handle: '1'
    run_cal: '0'
    sample_rate: samp_rate
    threads: '6'
  states: {}

connections:
- [sidekiq_sidekiq_rx_0, '0', qtgui_freq_sink_x_0, '0']
- [sidekiq_sidekiq_rx_0, '0', qtgui_time_sink_x_0, '0']
- [sidekiq_sidekiq_rx_0, '0', sidekiq_sidekiq_tx_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-605-g9b22fd38
