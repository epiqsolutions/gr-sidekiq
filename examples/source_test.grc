options:
  parameters:
    generate_options: qt_gui
    id: source_test
    output_language: python
    title: source_test
  states: {}

blocks:
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    start: 1e6
    step: 1e6
    stop: 250e6
    value: sample_rate * .8
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    start: 250e6
    step: 1e6
    stop: 6000e6
    value: 1000e6
  states: {}
- name: gain_index
  id: variable_qtgui_range
  parameters:
    label: Gain Index
    rangeType: int
    start: '0'
    step: '1'
    stop: '255'
    value: '10'
  states: {}
- name: run_rx_calibration
  id: variable_qtgui_push_button
  parameters:
    label: Run RX Calibration
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sample_rate
  id: variable_qtgui_range
  parameters:
    start: 1e6
    step: 1e6
    stop: 250e6
    value: 20e6
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: frequency
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    size: '1024'
    srate: '1'
    type: complex
  states: {}
- name: sidekiq_sidekiq_rx_0
  id: sidekiq_sidekiq_rx
  parameters:
    bandwidth: bandwidth
    cal_mode: '1'
    cal_type: '2'
    card: '1'
    frequency: frequency
    gain_index: gain_index
    gain_mode: '1'
    handle1: '0'
    handle2: '100'
    maxoutbuf: 1018 * 32
    run_cal: run_rx_calibration
    sample_rate: sample_rate
  states: {}

connections:
- [blocks_delay_0, '0', blocks_sub_xx_0, '1']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_1, '0']
- [sidekiq_sidekiq_rx_0, '0', blocks_delay_0, '0']
- [sidekiq_sidekiq_rx_0, '0', blocks_sub_xx_0, '0']
- [sidekiq_sidekiq_rx_0, '0', qtgui_freq_sink_x_0, '0']
- [sidekiq_sidekiq_rx_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
