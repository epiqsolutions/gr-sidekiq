options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Bandwidth
    start: .1e6
    step: 0.1e6
    stop: max_sample_rate
    value: max_sample_rate
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Frequency
    start: 100e6
    step: 1e6
    stop: 6000e6
    value: 915e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Gain
    start: '0'
    step: '1'
    stop: '2000'
    value: '0'
  states: {}
- name: max_sample_rate
  id: variable
  parameters:
    value: 56e6
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Sample Rate
    start: 1e6
    step: 1e6
    stop: max_sample_rate
    value: 40e6
  states: {}
- name: variable_function_probe_0
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_rate_0
    function_name: rate
    poll_rate: '10'
    value: '0'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    label: Rx Rate
    type: real
    value: variable_function_probe_0
  states: {}
- name: vector_length
  id: variable
  parameters:
    value: '1'
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vector_length
    type: complex
  states: {state: bypassed}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: center_freq
    fftsize: 4096*2
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: 1024*64
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"rx_rate"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: 2**14
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"rx_freq"'
    type: complex
  states: {}
- name: sidekiq_rx_0
  id: sidekiq_rx
  parameters:
    bandwidth: 1e6
    filter_override_taps: ''
    frequency: 2400e6
    gain: '1'
    gain_mode: '0'
    num_items: vector_length
    sample_rate: 1e6
    sync: '1'
  states: {}

connections:
- [blocks_conjugate_cc_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_throttle_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_probe_rate_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_tag_debug_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_1, '0']
- [sidekiq_rx_0, '0', blocks_throttle_0, '0']
- [sidekiq_rx_0, telemetry, blocks_message_debug_0, print]

metadata:
  file_format: 1
