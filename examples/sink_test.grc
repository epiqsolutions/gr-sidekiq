options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: atten_quart_db
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: 'Attenuation '
    start: '1'
    step: '1'
    stop: max_attenuation
    value: '55'
  states: {}
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Bandwidth
    start: 0.1e6
    step: 0.1e6
    stop: max_sample_rate
    value: sample_rate
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Frequency
    start: 100e6
    step: 1e6
    stop: 6000e6
    value: 915e6
  states: {}
- name: max_attenuation
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: max_sample_rate
  id: variable
  parameters:
    value: 122.88e6
  states: {}
- name: sample_rate
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Sample Rate
    start: 0.1e6
    step: 0.1e6
    stop: max_sample_rate
    value: 1e6
  states: {}
- name: source_min_output_buffer
  id: variable
  parameters:
    value: 2**14*4
  states: {}
- name: suppress_tune_transients_chooser
  id: variable_qtgui_chooser
  parameters:
    label: Suppress Tune Transients
    label0: 'False'
    label1: 'True'
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: variable_function_probe_0
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_rate_0
    function_name: rate
    poll_rate: '10'
    value: '0'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 5,0,1,1
    label: Rx Rate
    type: real
    value: variable_function_probe_0
  states: {}
- name: vector_length
  id: variable
  parameters:
    value: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0'
    freq: '1000'
    minoutbuf: source_min_output_buffer
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: sample_rate
    type: complex
  states: {state: bypassed}
- name: sidekiq_tx_0
  id: sidekiq_tx
  parameters:
    attenuation: '1'
    bandwidth: 1e6
    buffer_size: '16380'
    dataflow_mode: '0'
    filter_override_taps: ''
    frequency: 2400e6
    sample_rate: 1e6
    suppress_tune_transients: ''
    sync: '1'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: telemetry_message
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_probe_rate_0, '0']
- [blocks_throttle_0, '0', blocks_tag_debug_0, '0']
- [blocks_throttle_0, '0', sidekiq_tx_0, '0']
- [sidekiq_tx_0, telemetry, virtual_sink_0, '0']

metadata:
  file_format: 1
