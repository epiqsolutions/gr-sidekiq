options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: atten_quart_db
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: 'Attenuation '
    start: '0'
    step: '1'
    stop: max_attenuation
    value: '50'
  states: {}
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Bandwidth
    start: 0.1e6
    step: 0.1e6
    stop: max_sample_rate
    value: sample_rate
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Frequency
    start: 100e6
    step: 1e6
    stop: 6000e6
    value: 100e6
  states: {}
- name: max_attenuation
  id: variable
  parameters:
    value: '359'
  states: {}
- name: max_sample_rate
  id: variable
  parameters:
    value: 122.88e6
  states: {}
- name: sample_rate
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Sample Rate
    start: 0.1e6
    step: 0.1e6
    stop: max_sample_rate
    value: 10e6
  states: {}
- name: source_min_output_buffer
  id: variable
  parameters:
    value: 2**14*4
  states: {}
- name: suppress_tune_transients_chooser
  id: variable_qtgui_chooser
  parameters:
    label: Suppress Tune Transients
    label0: 'False'
    label1: 'True'
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: tone_freq
  id: variable_qtgui_range
  parameters:
    start: '1000000'
    step: '1000000'
    stop: '20000000'
    value: '2000000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.75'
    freq: tone_freq
    minoutbuf: source_min_output_buffer
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: sample_rate
    type: complex
  states: {}
- name: sidekiq_tx_0
  id: sidekiq_tx
  parameters:
    attenuation: atten_quart_db
    bandwidth: bandwidth
    buffer_size: '1020'
    dataflow_mode: '0'
    filter_override_taps: ''
    frequency: center_freq
    sample_rate: sample_rate
    suppress_tune_transients: '0'
    sync: '1'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: telemetry_message
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', sidekiq_tx_0, '0']
- [sidekiq_tx_0, telemetry, virtual_sink_0, '0']

metadata:
  file_format: 1
