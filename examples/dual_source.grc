options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Bandwidth
    start: .1e6
    step: 0.1e6
    stop: max_sample_rate
    value: 10e6
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Frequency
    start: 100e6
    step: 1e6
    stop: 6000e6
    value: 100e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Gain
    start: '0'
    step: '1'
    stop: '2000'
    value: '80'
  states: {}
- name: max_sample_rate
  id: variable
  parameters:
    value: 492e6
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Sample Rate
    start: 1e6
    step: 1e6
    stop: max_sample_rate
    value: 10e6
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1018'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1018'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: frequency
    fftsize: 4096*2
    name: stream 0
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: frequency
    fftsize: 4096*2
    name: stream 1
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: 1024*64
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"rx_rate"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: 1024*64
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"rx_rate"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: 2**14
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"rx_freq"'
    type: complex
  states: {}
- name: sidekiq_rx_0
  id: sidekiq_rx
  parameters:
    bandwidth: bandwidth
    card: '0'
    filter_override_taps: ''
    frequency: frequency
    gain: gain
    gain_mode: '0'
    port_id: '0'
    port_id2: '1'
    sample_rate: samp_rate
    sync_type: '1'
  states: {}

connections:
- [blocks_conjugate_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_conjugate_cc_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_conjugate_cc_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_conjugate_cc_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_conjugate_cc_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_conjugate_cc_0_0, '0']
- [sidekiq_rx_0, '0', blocks_vector_to_stream_0, '0']
- [sidekiq_rx_0, '1', blocks_vector_to_stream_0_0, '0']

metadata:
  file_format: 1
