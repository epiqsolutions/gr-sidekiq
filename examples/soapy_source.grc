options:
  parameters:
    generate_options: qt_gui
    id: source_test
    output_language: python
    title: source_test
  states: {}

blocks:
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    start: 1e6
    step: 1e6
    stop: 250e6
    value: sample_rate * .8
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    start: 250e6
    step: 1e6
    stop: 6000e6
    value: 1000e6
  states: {}
- name: gain_index
  id: variable_qtgui_range
  parameters:
    label: Gain Index
    rangeType: int
    start: '0'
    step: '1'
    stop: '255'
    value: '10'
  states: {}
- name: run_rx_calibration
  id: variable_qtgui_push_button
  parameters:
    label: Run RX Calibration
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sample_rate
  id: variable_qtgui_range
  parameters:
    start: 1e6
    step: 1e6
    stop: 250e6
    value: 50e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: frequency
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: '1'
    type: complex
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    agc0: 'True'
    center_freq0: frequency
    dev_args: card=2
    driver: sidekiq
    samp_rate: sample_rate
    type: fc32
  states: {}

connections:
- [soapy_custom_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_custom_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-605-g9b22fd38
