options:
  parameters:
    generate_options: no_gui
    id: telemetry
    output_language: python
    run_options: run
    title: telemetry
  states: {}

blocks:
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("temp")
    period: '1000'
  states: {}
- name: blocks_message_strobe_1
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("imu")
    period: '1000'
  states: {}
- name: sidekiq_telemetry_0
  id: sidekiq_telemetry
  parameters:
    imu_enabled: '0'
    input_card: '0'
    temp_enabled: '1'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, sidekiq_telemetry_0, temp]
- [blocks_message_strobe_1, strobe, sidekiq_telemetry_0, imu]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-495-g30aea759
