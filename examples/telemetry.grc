options:
  parameters:
    generate_options: qt_gui
    id: telemetry
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '10'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: sidekiq_telemetry_0
  id: sidekiq_telemetry
  parameters:
    card: '0'
    imu: '0'
    temp: '1'
  states: {}

connections:
- [sidekiq_telemetry_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
