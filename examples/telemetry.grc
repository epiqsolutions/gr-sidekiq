options:
  parameters:
    generate_options: qt_gui
    id: telemetry
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '10'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("temp")
    period: '1000'
  states: {}
- name: blocks_message_strobe_1
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("imu")
    period: '1000'
  states: {}
- name: sidekiq_telemetry_0
  id: sidekiq_telemetry
  parameters:
    imu_enabled: '0'
    input_card: '0'
    temp_enabled: '0'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, sidekiq_telemetry_0, temp]
- [blocks_message_strobe_1, strobe, sidekiq_telemetry_0, imu]

metadata:
  file_format: 1
  grc_version: 3.10.5.1
