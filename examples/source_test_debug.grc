options:
  parameters:
    generate_options: qt_gui
    id: source_test_debug
    output_language: python
    title: source_test_debug
  states: {}

blocks:
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    start: 1e5
    step: 1e6
    stop: 250e6
    value: sample_rate * .8
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    start: 250e6
    step: 1e6
    stop: 6000e6
    value: 1000e6
  states: {}
- name: gain_index
  id: variable_qtgui_range
  parameters:
    label: Gain Index
    rangeType: int
    start: '0'
    step: '1'
    stop: '255'
    value: '10'
  states: {}
- name: run_rx_calibration
  id: variable_qtgui_push_button
  parameters:
    label: Run RX Calibration
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sample_rate
  id: variable_qtgui_range
  parameters:
    start: 1e5
    step: 1e6
    stop: 250e6
    value: 1e6
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    maxoutbuf: '32000'
    minoutbuf: '32000'
    scale_factor: '2047.0'
    vector_output: 'False'
  states: {}
- name: blocks_endian_swap_0
  id: blocks_endian_swap
  parameters:
    type: s16
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: readable.bin
    type: short
  states: {state: disabled}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: samples.bin
    type: short
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_swapiq_0
  id: blocks_swapiq
  parameters:
    datatype: short
    maxoutbuf: '32000'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      rx_resolution = 12
      max_data = (1 << (rx_resolution -1))-1
      print(max_data)

      debug_ctr = 0
      byte_num = 0


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.int16],
                  out_sig=[np.int16]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).j
              self.example_param = example_param

          def work(self, input_items, output_items):
              global debug_ctr, byte_num
              
              
              expected = input_items[0][0]

              #validate samples
              for j in range(len(input_items[0])): 
                  this_value = input_items[0][j]

                  if (this_value != expected):
                      print("Fail: Byte # ", hex(byte_num + (j*2)), "expected", hex((0xffff & expected)), "actual", hex((0xffff & this_value)))                

                  expected = (this_value + 1)
                  if expected == (max_data + 1):
                      expected = -(max_data+1)
                      
                      
              debug_ctr += 1
              if debug_ctr % 1000 == 0:
                  print("ninput_items", len(input_items[0]))
                  
              byte_num = byte_num + (len(input_items[0]) * 2)
              
              return len(output_items[0])
    example_param: '1.0'
    maxoutbuf: '32000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: frequency
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: sidekiq_sidekiq_rx_0
  id: sidekiq_sidekiq_rx
  parameters:
    bandwidth: bandwidth
    cal_mode: '0'
    cal_type: '2'
    card: '1'
    frequency: frequency
    gain_index: gain_index
    gain_mode: '1'
    handle1: '0'
    handle2: '100'
    maxoutbuf: '32000'
    run_cal: run_rx_calibration
    sample_rate: sample_rate
  states: {}

connections:
- [blocks_complex_to_interleaved_short_0, '0', blocks_swapiq_0, '0']
- [blocks_endian_swap_0, '0', blocks_file_sink_0, '0']
- [blocks_swapiq_0, '0', blocks_endian_swap_0, '0']
- [blocks_swapiq_0, '0', blocks_file_sink_2, '0']
- [blocks_swapiq_0, '0', epy_block_0, '0']
- [epy_block_0, '0', blocks_null_sink_0, '0']
- [sidekiq_sidekiq_rx_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [sidekiq_sidekiq_rx_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
