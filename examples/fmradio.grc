options:
  parameters:
    generate_options: qt_gui
    id: fmradio
    output_language: python
    title: FM Radio
  states: {}

blocks:
- name: channel
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '88100000'
    step: '200000'
    stop: '107900000'
    value: '91500000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '5000000'
  states: {}
- name: volume
  id: variable_qtgui_dial_control
  parameters:
    label: volume
    maximum: '100'
    minimum: '0'
    minsize: '1'
    showvalue: 'True'
    type: int
    value: '1'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: '500000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1018'
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100000'
    decim: '10'
    gain: '1'
    samp_rate: '5000000'
    type: fir_filter_ccf
    width: '1000000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: channel
    fftsize: 4096*2
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: 1024*64
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"rx_rate"'
    type: complex
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '48'
    type: fff
  states: {}
- name: sidekiq_rx_0
  id: sidekiq_rx
  parameters:
    bandwidth: samp_rate
    card: '0'
    filter_override_taps: ''
    frequency: channel
    gain: '1'
    gain_mode: '1'
    port_id: '0'
    port_id2: '100'
    sample_rate: samp_rate
    sync_type: '1'
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_1, '0']
- [blocks_conjugate_cc_0, '0', low_pass_filter_0, '0']
- [blocks_conjugate_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_conjugate_cc_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_conjugate_cc_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [sidekiq_rx_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
