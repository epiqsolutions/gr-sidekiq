options:
  parameters:
    generate_options: qt_gui
    id: single_record
    output_language: python
    title: single_record
  states: {}

blocks:
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: samp_rate
    start: 1e6
    step: 1e6
    stop: 500e6
    value: 20e6
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '32767'
    vector_output: 'False'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ch1.bin
    type: short
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: sidekiq_sidekiq_rx_0
  id: sidekiq_sidekiq_rx
  parameters:
    bandwidth: samp_rate* 0.9
    cal_mode: '0'
    cal_type: '0'
    card: '2'
    frequency: 1000e6
    gain_index: '1'
    gain_mode: '1'
    handle1: '0'
    handle2: '100'
    pps_source: '0'
    run_cal: '0'
    sample_rate: samp_rate
    trigger_src: '0'
  states: {}

connections:
- [blocks_complex_to_interleaved_short_0, '0', blocks_file_sink_0, '0']
- [sidekiq_sidekiq_rx_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [sidekiq_sidekiq_rx_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-375-ge2af6089
