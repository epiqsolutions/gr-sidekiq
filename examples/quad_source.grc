options:
  parameters:
    generate_options: qt_gui
    id: quad_source
    output_language: python
    title: quad_source
  states: {}

blocks:
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    start: 1e6
    step: 1e6
    stop: 250e6
    value: sample_rate * .8
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    start: 250e6
    step: 1e6
    stop: 6000e6
    value: 1000e6
  states: {}
- name: run_rx_calibration
  id: variable_qtgui_push_button
  parameters:
    label: Run RX Calibration
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sample_rate
  id: variable_qtgui_range
  parameters:
    start: 1e6
    step: 1e6
    stop: 250e6
    value: 250e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: frequency
    fftsize: '1024'
    name: '"Channel 0"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: frequency
    fftsize: '1024'
    name: '"Channel 1"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: frequency
    fftsize: '1024'
    name: '"Channel 2"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: frequency
    fftsize: '1024'
    name: '"Channel 3"'
    type: complex
  states: {}
- name: sidekiq_sidekiq_rx_0
  id: sidekiq_sidekiq_rx
  parameters:
    bandwidth: bandwidth
    cal_mode: '1'
    cal_type: '2'
    card: '0'
    frequency: frequency
    gain_index: '1'
    gain_mode: '1'
    handle1: '0'
    handle2: '1'
    handle3: '2'
    handle4: '3'
    pps_source: '0'
    run_cal: run_rx_calibration
    sample_rate: sample_rate
    timestamp_tags: '0'
    trigger_src: '0'
  states: {}

connections:
- [sidekiq_sidekiq_rx_0, '0', qtgui_freq_sink_x_0, '0']
- [sidekiq_sidekiq_rx_0, '1', qtgui_freq_sink_x_0_0, '0']
- [sidekiq_sidekiq_rx_0, '2', qtgui_freq_sink_x_0_0_0, '0']
- [sidekiq_sidekiq_rx_0, '3', qtgui_freq_sink_x_0_0_1, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-605-g9b22fd38
