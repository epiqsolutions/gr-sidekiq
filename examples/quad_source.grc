options:
  parameters:
    generate_options: qt_gui
    id: quad_source
    output_language: python
    title: quad_source
  states: {}

blocks:
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    start: 1e6
    step: 1e6
    stop: 250e6
    value: sample_rate * .8
  states: {}
- name: frequency1
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    start: 250e6
    step: 1e6
    stop: 6000e6
    value: 1000e6
    widget: slider
  states: {}
- name: frequency2
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0,1,1
    start: 250e6
    step: 1e6
    stop: 6000e6
    value: 1000e6
    widget: slider
  states: {}
- name: frequency3
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,0,1,1
    start: 250e6
    step: 1e6
    stop: 6000e6
    value: 1000e6
    widget: slider
  states: {}
- name: frequency4
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,0,1,1
    start: 250e6
    step: 1e6
    stop: 6000e6
    value: 1000e6
    widget: slider
  states: {}
- name: run_rx_calibration
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 2,0,1,1
    label: Run RX Calibration
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sample_rate
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    start: 1e6
    step: 1e6
    stop: 250e6
    value: 50e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: frequency1
    fftsize: '1024'
    gui_hint: 4,0,1,1
    name: '"Channel 1"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: sample_rate
    fc: frequency2
    fftsize: '1024'
    gui_hint: 6,0,1,1
    name: '"Channel 2"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: frequency3
    fftsize: '1024'
    gui_hint: 8,0,1,1
    name: '"Channel 3"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: frequency4
    fftsize: '1024'
    gui_hint: 10,0,1,1
    name: '"Channel 4"'
    type: complex
  states: {}
- name: sidekiq_sidekiq_rx_0
  id: sidekiq_sidekiq_rx
  parameters:
    bandwidth: bandwidth
    cal_mode: '0'
    cal_type: '0'
    card: '0'
    frequency1: frequency1
    frequency2: frequency2
    frequency3: frequency3
    frequency4: frequency4
    gain_index: '200'
    gain_mode: '1'
    handle1: '0'
    handle2: '1'
    handle3: '2'
    handle4: '3'
    num_handles: '4'
    pps_source: '0'
    run_cal: '0'
    sample_rate: sample_rate
    timestamp_tags: '0'
    trigger_src: '0'
  states: {}

connections:
- [sidekiq_sidekiq_rx_0, '0', qtgui_freq_sink_x_0, '0']
- [sidekiq_sidekiq_rx_0, '1', qtgui_freq_sink_x_0_0, '0']
- [sidekiq_sidekiq_rx_0, '2', qtgui_freq_sink_x_0_0_0, '0']
- [sidekiq_sidekiq_rx_0, '3', qtgui_freq_sink_x_0_0_1, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-605-g9b22fd38
